# Keil uVision project ANO_LX_FC.uvprojx, settings and files
target ANO_LX_FC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ANO_LX_FC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,CONFIG_USB_DWC2_PORT=FS_PORT
  c include: ProjectSTM32F407\build;FcSrc;DriversBsp;DriversMcu\STM32F407\Drivers;DriversMcu\STM32F407\Libraries\STM32F4xx_StdPeriph_Driver\inc;DriversMcu\STM32F407\Libraries\CMSIS\Include;DriversMcu\STM32F407\Libraries\CMSIS\ST\STM32F4xx\Include;DriversMcu\STM32F407;.cmsis\dsp_lib;.cmsis\include;ProjectSTM32F407\RTE\_Ano_LX;.eide\deps;ThirdParty\CherryUSB\core;ThirdParty\CherryUSB\common;ThirdParty\CherryUSB\class\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group LibrariesMcu
    DriversMcu/STM32F407/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    DriversMcu/STM32F407/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    DriversMcu/STM32F407/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group FcSrc
    FcSrc/: ANO_DT_LX.c ANO_DT_LX.h ANO_LX.c ANO_LX.h Ano_Scheduler.c Ano_Scheduler.h cdc_acm.c LD_Radar.c LX_FC_EXT_Sensor.c LX_FC_EXT_Sensor.h LX_FC_Fun.c LX_FC_Fun.h LX_FC_State.c LX_FC_State.h main.c SysConfig.h Uart_Screen.c User_Com.c User_Com.h User_Task.c User_Task.h Wireless_Com.c
  group DriversMcu
    DriversMcu/STM32F407/Drivers/: Drv_adc.c Drv_adc.h Drv_led.c Drv_led.h Drv_Misc.c Drv_Misc.h Drv_PwmOut.c Drv_PwmOut.h Drv_RcIn.c Drv_RcIn.h Drv_Sys.c Drv_Sys.h Drv_Timer.c Drv_Timer.h Drv_Uart.c Drv_Uart.h Drv_WS2812.c Drv_WS2812.h stm32f4xx_conf.h stm32f4xx_it.c
    DriversMcu/STM32F407/: McuConfig.h
  group DriversBsp
    DriversBsp/: Ano_Math.c Ano_Math.h Drv_AnoOf.c Drv_AnoOf.h Drv_BSP.c Drv_BSP.h Drv_key.c Drv_key.h Drv_UpFlow.c
  group CherryUSB
    ThirdParty/CherryUSB/class/cdc/: usbd_cdc.c
    ThirdParty/CherryUSB/core/: usbd_core.c
    ThirdParty/CherryUSB/port/dwc2/: usb_dc_dwc2.c
