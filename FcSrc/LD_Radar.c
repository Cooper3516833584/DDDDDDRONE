/**
 * @file LD_Radar.c
 * @brief Rader module source file
 * @author Ellu (lutaoyu@163.com)
 * @version 1.0
 * @date 2023-07-14
 *
 * THINK DIFFERENTLY
 */

#include "LD_Radar.h"

#include "ANO_DT_LX.h"
#include "User_Com.h"
#include "string.h"

const u8 crc8_table[] = {
    0x00, 0x4D, 0x9A, 0xD7, 0x79, 0x34, 0xE3, 0xAE,
    0xF2, 0xBF, 0x68, 0x25, 0x8B, 0xC6, 0x11, 0x5C,  // 0x00 - 0x0F
    0xA9, 0xE4, 0x33, 0x7E, 0xD0, 0x9D, 0x4A, 0x07,
    0x5B, 0x16, 0xC1, 0x8C, 0x22, 0x6F, 0xB8, 0xF5,  // 0x10 - 0x1F
    0x1F, 0x52, 0x85, 0xC8, 0x66, 0x2B, 0xFC, 0xB1,
    0xED, 0xA0, 0x77, 0x3A, 0x94, 0xD9, 0x0E, 0x43,  // 0x20 - 0x2F
    0xB6, 0xFB, 0x2C, 0x61, 0xCF, 0x82, 0x55, 0x18,
    0x44, 0x09, 0xDE, 0x93, 0x3D, 0x70, 0xA7, 0xEA,  // 0x30 - 0x3F
    0x3E, 0x73, 0xA4, 0xE9, 0x47, 0x0A, 0xDD, 0x90,
    0xCC, 0x81, 0x56, 0x1B, 0xB5, 0xF8, 0x2F, 0x62,  // 0x40 - 0x4F
    0x97, 0xDA, 0x0D, 0x40, 0xEE, 0xA3, 0x74, 0x39,
    0x65, 0x28, 0xFF, 0xB2, 0x1C, 0x51, 0x86, 0xCB,  // 0x50 - 0x5F
    0x21, 0x6C, 0xBB, 0xF6, 0x58, 0x15, 0xC2, 0x8F,
    0xD3, 0x9E, 0x49, 0x04, 0xAA, 0xE7, 0x30, 0x7D,  // 0x60 - 0x6F
    0x88, 0xC5, 0x12, 0x5F, 0xF1, 0xBC, 0x6B, 0x26,
    0x7A, 0x37, 0xE0, 0xAD, 0x03, 0x4E, 0x99, 0xD4,  // 0x70 - 0x7F
    0x7C, 0x31, 0xE6, 0xAB, 0x05, 0x48, 0x9F, 0xD2,
    0x8E, 0xC3, 0x14, 0x59, 0xF7, 0xBA, 0x6D, 0x20,  // 0x80 - 0x8F
    0xD5, 0x98, 0x4F, 0x02, 0xAC, 0xE1, 0x36, 0x7B,
    0x27, 0x6A, 0xBD, 0xF0, 0x5E, 0x13, 0xC4, 0x89,  // 0x90 - 0x9F
    0x63, 0x2E, 0xF9, 0xB4, 0x1A, 0x57, 0x80, 0xCD,
    0x91, 0xDC, 0x0B, 0x46, 0xE8, 0xA5, 0x72, 0x3F,  // 0xA0 - 0xAF
    0xCA, 0x87, 0x50, 0x1D, 0xB3, 0xFE, 0x29, 0x64,
    0x38, 0x75, 0xA2, 0xEF, 0x41, 0x0C, 0xDB, 0x96,  // 0xB0 - 0xBF
    0x42, 0x0F, 0xD8, 0x95, 0x3B, 0x76, 0xA1, 0xEC,
    0xB0, 0xFD, 0x2A, 0x67, 0xC9, 0x84, 0x53, 0x1E,  // 0xC0 - 0xCF
    0xEB, 0xA6, 0x71, 0x3C, 0x92, 0xDF, 0x08, 0x45,
    0x19, 0x54, 0x83, 0xCE, 0x60, 0x2D, 0xFA, 0xB7,  // 0xD0 - 0xDF
    0x5D, 0x10, 0xC7, 0x8A, 0x24, 0x69, 0xBE, 0xF3,
    0xAF, 0xE2, 0x35, 0x78, 0xD6, 0x9B, 0x4C, 0x01,  // 0xE0 - 0xEF
    0xF4, 0xB9, 0x6E, 0x23, 0x8D, 0xC0, 0x17, 0x5A,
    0x06, 0x4B, 0x9C, 0xD1, 0x7F, 0x32, 0xE5, 0xA8,  // 0xF0 - 0xFF
};

u8 calc_crc8(u8* buf, u32 len) {
  u8 crc = 0;
  while (len--) {
    crc = crc8_table[crc ^ *buf++];
  }
  return crc;
}

#define RADAR_MULTI_PACK 1  // 是否多包发送

#if RADAR_MULTI_PACK

// 收到几包雷达数据后发送一次(最大5包, 因为包长度限制)
#define LD_RADAR_REPORT_CNT 4
// 一个包字节, 固定转速2字节, 包头4字节
#define LD_RADAR_SINGLE_PACK_SIZE 42
#define LD_RADAR_PACK_SIZE LD_RADAR_REPORT_CNT* LD_RADAR_SINGLE_PACK_SIZE + 6

static u8 radar_raw_buf[48] = {0};
static u8 radar_buf[LD_RADAR_PACK_SIZE + 1] = {0xAA, 0x55, 0x2D, 0x04, 0};
static u8 radar_cnt = 0;

extern void cdc_acm_data_send(uint8_t* buf, uint32_t len);

void LD_Radar_DataSend() {
  radar_buf[0] = 0xAA;                    // header1
  radar_buf[1] = 0x55;                    // header2
  radar_buf[2] = LD_RADAR_PACK_SIZE - 3;  // length
  radar_buf[3] = 0x04;                    // custom id
  radar_buf[LD_RADAR_PACK_SIZE] = 0;      // checksum
  for (int i = 0; i < LD_RADAR_PACK_SIZE; i++) {
    radar_buf[LD_RADAR_PACK_SIZE] += radar_buf[i];
  }
  cdc_acm_data_send(radar_buf, LD_RADAR_PACK_SIZE + 1);
}

void LD_Radar_AddPackage(void) {
  radar_buf[4] = radar_raw_buf[2];  // speed
  radar_buf[5] = radar_raw_buf[3];
  memcpy(radar_buf + 6 + radar_cnt * LD_RADAR_SINGLE_PACK_SIZE,
         radar_raw_buf + 4, 40);
  radar_cnt++;
  if (radar_cnt == LD_RADAR_REPORT_CNT) {
    LD_Radar_DataSend();
    radar_cnt = 0;
  }
}

void LD_Radar_GetOneByte(u8 data) {
  static u8 data_cnt = 0;
  static u8 state = 0;
  if (!user_connected) return;
  if (state == 0 && data == 0x54) {  // header1
    state = 1;
    radar_raw_buf[0] = data;
  } else if (state == 1 && data == 0x2C) {  // header2
    state = 2;
    data_cnt = 0;
    radar_raw_buf[1] = data;
  } else if (state == 2) {  // 44 bytes data
    radar_raw_buf[(data_cnt++) + 2] = data;
    if (data_cnt == 44) {
      state = 3;
    }
  } else if (state == 3) {  // crc
    if (calc_crc8(radar_raw_buf, 46) == data) {
      LD_Radar_AddPackage();
    } else {
      LxStringSend(LOG_COLOR_RED, "radar crc error");
    }
    state = 0;
  } else {
    state = 0;
  }
}

#else

static u8 radar_buf[64] = {0xAA, 0x55, 0x2D, 0x04, 0};

extern void cdc_acm_data_send(uint8_t* buf, uint32_t len);

void LD_Radar_DataSend() {
  radar_buf[0] = 0xAA;  // header1
  radar_buf[1] = 0x55;  // header2
  radar_buf[2] = 0x2D;  // length
  radar_buf[3] = 0x04;  // custom id
  radar_buf[48] = 0;    // checksum
  for (int i = 0; i < 48; i++) {
    radar_buf[48] += radar_buf[i];
  }
  cdc_acm_data_send(radar_buf, 49);
}
void LD_Radar_GetOneByte(u8 data) {
  static u8 data_cnt = 0;
  static u8 state = 0;
  if (!user_connected) return;
  if (state == 0 && data == 0x54) {  // header1
    state = 1;
    radar_buf[2] = data;
  } else if (state == 1 && data == 0x2C) {  // header2
    state = 2;
    data_cnt = 0;
    radar_buf[3] = data;
  } else if (state == 2) {  // 44 bytes data
    radar_buf[(data_cnt++) + 4] = data;
    if (data_cnt == 44) {
      state = 3;
    }
  } else if (state == 3) {  // crc
    if (calc_crc8(radar_buf + 2, 46) == data) {
      LD_Radar_DataSend();
    } else {
      LxStringSend(LOG_COLOR_RED, "radar crc error");
    }
    state = 0;
  } else {
    state = 0;
  }
}
#endif  // RADAR_MULTI_PACK
